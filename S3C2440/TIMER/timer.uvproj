# Keil uVision project timer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: timer
  AfterMake: fromelf.exe --bin -o @p.bin .\@p.axf
  c flags: Optim=1
  c misc: -O1 -g -W
  c include: .\inc;.\src
  asm define: __EVAL
  asm include: .\inc
  memory RVCT4: ROM 0x30000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --first 2440init.o(Reset)
  group Source Group 1
    ./src/: 2440init.s 2440lib.c 2440slib.s Main.c mmu.c
