# Keil uVision project beep_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: beep_test
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  memory RVCT1: ROM 0x30000000 size 0x10000
  group Source Group 1
    ./: beep_test.s
